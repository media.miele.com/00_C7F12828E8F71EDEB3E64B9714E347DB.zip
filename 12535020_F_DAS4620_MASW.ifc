Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 18810eb6-2f55-4001-81c1-d56f94e4ab00, NumberOfSaves: 1]
File name: 0001
Time: 2024-02-12T13:34:14+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12535020_F_DAS4620_MASW:28S4620M_F_12535020_DAS4620_MASW, (2)
In: Default
Type - Material: Výchozí Nový materiál, z_Miele_Design_Steel_Chrom, z_Miele_Design_Zinc_Steel, <Unnamed>, z_Miele_Design_CLST, Plast, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Cast, z_Miele_Design_GRGR
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 28S4620M_F_12535020_DAS4620_MASW; sets with these values: 2
Pset_ProvisionForVoid - Width: 252 mm; Height: 27 mm; Depth: 27 mm

# IfcDistributionPort, Port_354602_1
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOpeningElement: Opening, :1
In: Default
Pset_OpeningElementCommon - Reference: 28S4620M_F_12535020_DAS4620_MASW; sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment
